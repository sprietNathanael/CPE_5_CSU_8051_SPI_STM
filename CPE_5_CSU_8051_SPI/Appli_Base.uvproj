# Keil uVision project Appli_Base.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Executable
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c init.c Asm_8051_Lib.asm
